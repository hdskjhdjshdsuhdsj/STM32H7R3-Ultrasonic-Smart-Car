# Keil uVision project TANK5_TEST_Boot.uvprojx, settings and files
target TANK5_TEST_Boot (6220000::V6.22::ARMCLANG)
  device: STM32H7R3L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.1
  cpu: IRAM(0x00000000,0x00010000) IRAM2(0x20000000,0x00010000) IROM(0x08000000,0x00010000) XRAM(0x24000000,0x00072000) XRAM2(0x30000000,0x00008000) XRAM3(0x38800000,0x00001000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TANK5_TEST_Boot +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7R3xx
  c include: ../../Boot/Core/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include;../Boot
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x24000000 size 0x72000
  memory RVCT7: RAM 0x30000000 size 0x8000
  memory RVCT8: RAM 0x38800000 size 0x1000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: stm32h7r3xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7r3xx.s
  group Application/User/Boot/Core
    ./: PWM.c pwm.h car.c car.h ultrasonic.c ultrasonic.h sys.h ax_utsc.h ax_delay.h ax_delay.c ax_sys.c ax_sys.h hycg.c hycg.h
    ../../Boot/Core/Src/: main.c gpio.c tim.c usart.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Drivers/CMSIS
    ../../Boot/Core/Src/: system_stm32h7rsxx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_tim.c stm32h7rsxx_hal_tim_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c
software components: CMSIS:CORE 6.1.0
